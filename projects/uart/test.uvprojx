# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT32F403ACCU7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LIBRARY_VERSION
  c include: .\USER;.\Platform\Core;.\Platform\lv_port;.\Platform;.\ArduinoAPI;.\ArduinoAPI\avr
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group User
    ./USER/: main.cpp
  group platform
    ./Platform/Core/: mcu_core.c delay.c gpio.c adc.c extend_SRAM.c exti.c i2c.c wdg.c timer.c rtc.c pwm.c
  group arduino
    ./ArduinoAPI/: Arduino.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1, Device:StdPeriph Drivers:ADC 1.0.1, Device:StdPeriph Drivers:BKPR 1.0.1, Device:StdPeriph Drivers:DMA 1.0.1, Device:StdPeriph Drivers:EXTI 1.0.1, Device:StdPeriph Drivers:FMC 1.0.1, Device:StdPeriph Drivers:Framework 1.0.1, Device:StdPeriph Drivers:GPIO 1.0.1, Device:StdPeriph Drivers:I2C 1.0.1, Device:StdPeriph Drivers:IWDG 1.0.1, Device:StdPeriph Drivers:PWR 1.0.1, Device:StdPeriph Drivers:RCC 1.0.1, Device:StdPeriph Drivers:RTC 1.0.1, Device:StdPeriph Drivers:SPI 1.0.1, Device:StdPeriph Drivers:TIMER 1.0.1, Device:StdPeriph Drivers:USART 1.0.1, Device:System_AT32Fxx 1.0.1
